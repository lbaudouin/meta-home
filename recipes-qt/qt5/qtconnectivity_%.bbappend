DEPENDS_remove = "qtdeclarative"
DEPENDS += " bluez5 "
EXTRA_QMAKEVARS_PRE += " CONFIG+=config_bluez "

